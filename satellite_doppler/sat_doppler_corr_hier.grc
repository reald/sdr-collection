options:
  parameters:
    author: reald
    generate_options: hb
    id: sat_doppler_corr
    output_language: python
    run_options: run
    title: Satellite Doppler Frequency Shift Correction
  states: {}

blocks:
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Correction frequency will be set by message
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import blocks

      import pmt

      from orbit_predictor.sources import EtcTLESource
      import orbit_predictor.locations
      import datetime
      import pytz


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1e6,
                       rx_freq=145.8e6,
                       loc_name='Nuernberg', loc_lat=49.478, loc_lon=11.069, loc_height_m=315, 
                       tle_file='/home/real/iss.txt', sat_name='ISS (ZARYA)',
                       start_time='2021-01-01 00:00:00',
                       time_zone='Europe/Berlin',
                       print_debug=1):
              """arguments to this function show up as parameters in GRC"""

              gr.sync_block.__init__(
                  self,
                  name='Satellite Doppler Shift Prediction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.message_port_register_out(pmt.intern('msgfreq'))
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              # sample rate
              self.samp_rate = samp_rate
              
              # rx frequency
              self.rx_freq = rx_freq
              
              # location
              self.loc_name = loc_name
              self.loc_lat = loc_lat
              self.loc_lon = loc_lon
              self.loc_height_m = loc_height_m
              self.location = orbit_predictor.locations.Location(self.loc_name, self.loc_lat, self.loc_lon, self.loc_height_m)
              
              # read iss tle
              self.tle_file = tle_file
              self.tlesource = EtcTLESource(filename=self.tle_file)

              # sat predictor
              self.sat_name = sat_name
              print("Satellite: " + self.sat_name)
              self.satpredictor = self.tlesource.get_predictor(self.sat_name)
              
              # destination timezone
              try:
                 self.time_zone = pytz.timezone(time_zone)
              except:
                 print("Falling back to UTC")
                 self.time_zone = pytz.timezone('UTC')
              
              print("Timezone: " + str(self.time_zone) )
              
              self.time_zone_utc = pytz.timezone('UTC')
              
              # start time
              try:
                 self.start_time = datetime.datetime.strptime(start_time, '%Y-%m-%d %H:%M:%S')
                 self.start_time = self.time_zone.localize(self.start_time)
              except:
                 print("No valid start time given. Use now()")
                 self.start_time = datetime.datetime.now(self.time_zone)

              print("Start time: " + str(self.start_time) )
              
              self.start_time_utc = self.start_time.astimezone(self.time_zone_utc)
              self.current_time_utc = self.start_time_utc

              self.print_debug = print_debug

              # other variables
              self.num_seen_samples = 0
              self.num_delta_samples = 0
              self.last_freq_corr_msg = 0



          def get_sat_elev_azim(self, sat_position):
             """ get elevation and azimuth on our location to sat at its position """
             
             [azim, elev] = self.location.get_azimuth_elev_deg( sat_position )
             
             return [elev, azim]



          def get_doppler_factor(self, sat_position):
             """ get doppler factor """
             
             return self.location.doppler_factor( sat_position )



          def get_doppler_shift(self, sat_position, freq):
             """ get doppler factor """
             
             return round(freq - self.location.doppler_factor( sat_position ) * freq)



          def get_sat_distance(self, sat_position_efec):
             """ get distance to satellite """
             
             return self.location.slant_range_km( sat_position_efec )



          def get_sat_distance_velocity(self, sat_position):
             """ get distance to satellite """
             
             return self.location.slant_range_velocity_kms( sat_position )
          


          def get_is_visible(self, sat_position):
             """ is satellite visible from our location? """
             
             return self.location.is_visible ( sat_position )



          def print_sat_info(self, sat_pos):
             """ print information at location of sat at position """
             
             if ( self.print_debug == 0 ):
                return
             
             # elevation and azimuth of satellite at our location
             [elev, azim] = self.get_sat_elev_azim(sat_pos)
             print( "Elevation: " + str(elev) + ", Azimuth: " + str(azim) )
                 
             # doppler factor
             print( "Doppler Factor: " + str(self.get_doppler_factor(sat_pos)) )
                 
             # doppler shift
             print( "Doppler Shift (@100M, Hz): " + str(self.get_doppler_shift(sat_pos, 100e6)) )
             print( "Doppler Shift (@" + str(self.rx_freq) + ", Hz): " + str(self.get_doppler_shift(sat_pos, self.rx_freq)) )

             # distance
             print ( "Distance (km): " + str(self.get_sat_distance(sat_pos.position_ecef)) )
                 
             # distance velocity
             print ( "Slant range velocity (km/s): " + str(self.get_sat_distance_velocity(sat_pos)) )
                 
             # is sat visible from this location?
             print ( "Sat visible from location: " + str(self.get_is_visible(sat_pos)) )

             print("")
             
             

          def work(self, input_items, output_items):
              """ worker """
             
              #print(self.num_delta_samples)
              
              if self.num_seen_samples == 0:
                 # first call. calculate start time
                 
                 # get next pass
                 #print(self.start_time_utc.tzinfo)
                 # sat predictor expects utc time
                 predicted_pass = self.satpredictor.get_next_pass(self.location, self.start_time_utc, max_elevation_gt = 0)
                 print(predicted_pass.aos.tzinfo)
                 print(predicted_pass.aos, predicted_pass.los, predicted_pass.duration_s, predicted_pass.max_elevation_deg, sep="; ")
                 # local time
                 print(predicted_pass.aos.astimezone(self.time_zone))
               
                 sat_pos = self.satpredictor.get_position(self.start_time_utc)
                 self.print_sat_info(sat_pos)

                 # send frequency correction message
                 doppler_freq_corr = - self.get_doppler_shift(sat_pos, self.rx_freq)
                 self.message_port_pub(pmt.intern('msgfreq'), pmt.cons(pmt.to_pmt("freq"), pmt.from_float(doppler_freq_corr)))
                 self.last_freq_corr_msg = doppler_freq_corr
               
              elif (self.num_delta_samples > self.samp_rate):
                 # recalculate time after min 1s
                 
                 self.current_time_utc = self.current_time_utc + datetime.timedelta( seconds = self.num_delta_samples/self.samp_rate )
                 print( self.current_time_utc.astimezone(self.time_zone) )

                 sat_pos = self.satpredictor.get_position(self.current_time_utc)
                 self.print_sat_info(sat_pos)
                 
                 # send frequency correction message
                 doppler_freq_corr = - self.get_doppler_shift(sat_pos, self.rx_freq)
                 
                 if ( doppler_freq_corr != self.last_freq_corr_msg ):
                    # only send if change happended
                    self.message_port_pub(pmt.intern('msgfreq'), pmt.cons(pmt.to_pmt("freq"), pmt.from_float(doppler_freq_corr)))
                    self.last_freq_corr_msg = doppler_freq_corr

                 self.num_delta_samples = 0

              self.num_seen_samples += len(input_items[0])
              self.num_delta_samples += len(input_items[0]) 

              output_items[0][:] = input_items[0]

              
              return len(output_items[0])
    loc_height_m: loc_height
    loc_lat: loc_lat
    loc_lon: loc_lon
    loc_name: loc_name
    print_debug: print_debug
    rx_freq: rx_freq
    samp_rate: samp_rate
    sat_name: sat_name
    start_time: start_time
    time_zone: time_zone
    tle_file: tle_file
  states: {}
- name: loc_height
  id: parameter
  parameters:
    label: Location Height [m]
    value: '315'
  states: {}
- name: loc_lat
  id: parameter
  parameters:
    label: Location Latitude
    value: '49.478'
  states: {}
- name: loc_lon
  id: parameter
  parameters:
    label: Location Longitude
    value: '11.069'
  states: {}
- name: loc_name
  id: parameter
  parameters:
    comment: Receiver Location
    label: Location Name
    type: str
    value: '''Nuremberg'''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: print_debug
  id: parameter
  parameters:
    hide: part
    label: Print Debug Messages
    type: intx
    value: '0'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: Receive Frequency
    value: 145.8e6
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '32000'
  states: {}
- name: sat_name
  id: parameter
  parameters:
    label: Satellite Name
    type: str
    value: '''ISS (ZARYA)'''
  states: {}
- name: start_time
  id: parameter
  parameters:
    label: Start Time
    type: str
    value: '''2021-01-02 08:09:15'''
  states: {}
- name: time_zone
  id: parameter
  parameters:
    label: Time Zone
    type: str
    value: '''Europe/Berlin'''
  states: {}
- name: tle_file
  id: parameter
  parameters:
    label: Location of TLE file
    type: str
    value: /tmp/iss.txt
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0, msgfreq, analog_sig_source_x_0_0, freq]
- [epy_block_0, msgfreq, blocks_message_debug_0, print]
- [pad_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
