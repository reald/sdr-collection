options:
  parameters:
    author: reald
    generate_options: qt_gui
    id: sat_doppler_corr_example
    output_language: python
    title: sat_doppler_corr_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Correction frequency will be set by message
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sat_signal_doppler_fix1.cfile
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sat_signal_doppler_fix2.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/satellite_signal.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Doppler Shift Correction
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: May be faster than real time
    samples_per_second: samp_rate*8
    type: complex
  states: {}
- name: direction
  id: parameter
  parameters:
    label: Direction (RX/TX)
    type: str
    value: '''RX'''
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import blocks

      import pmt

      from orbit_predictor.sources import EtcTLESource
      import orbit_predictor.locations
      import datetime
      import pytz


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1e6,
                       rx_freq=145.8e6,
                       direction='RX',
                       loc_name='Nuernberg', loc_lat=49.478, loc_lon=11.069, loc_height_m=315, 
                       tle_file='/home/real/iss.txt', sat_name='ISS (ZARYA)',
                       start_time='2021-01-01 00:00:00',
                       time_zone='Europe/Berlin',
                       print_debug=1):
              """arguments to this function show up as parameters in GRC"""

              gr.sync_block.__init__(
                  self,
                  name='Satellite Doppler Shift Correction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              print("*** Satellite Doppler Frequency Shift Correction ***")
              
              # sample rate
              self.samp_rate = samp_rate
              
              # rx frequency
              self.rx_freq = rx_freq
              
              # rx or tx correction?
              if direction.lower() == 'rx':
                 self.direction = -1
              else:
                 self.direction = 1
                 
              # location
              self.loc_name = loc_name
              self.loc_lat = loc_lat
              self.loc_lon = loc_lon
              self.loc_height_m = loc_height_m
              self.location = orbit_predictor.locations.Location(self.loc_name, self.loc_lat, self.loc_lon, self.loc_height_m)
              
              # read iss tle
              self.tle_file = tle_file
              self.tlesource = EtcTLESource(filename=self.tle_file)

              # sat predictor
              self.sat_name = sat_name
              print("Satellite: " + self.sat_name)
              self.satpredictor = self.tlesource.get_predictor(self.sat_name)
              
              # destination timezone
              try:
                 self.time_zone = pytz.timezone(time_zone)
              except:
                 print("WARNING: Invalid time zone. Assuming UTC.")
                 self.time_zone = pytz.timezone('UTC')
              
              self.time_zone_utc = pytz.timezone('UTC')
              
              # start time
              try:
                 self.start_time = datetime.datetime.strptime(start_time, '%Y-%m-%d %H:%M:%S')
                 self.start_time = self.time_zone.localize(self.start_time)
              except:
                 print("WARNING: No valid start time given. Use now()")
                 self.start_time = datetime.datetime.now(self.time_zone)

              self.current_time_utc = self.start_time.astimezone(self.time_zone_utc)
              print("Start Time: " + str(self.current_time_utc.astimezone(self.time_zone)) + " (" + str(self.time_zone) + ")" )
                 
              self.print_debug = print_debug

              # other variables
              self.num_delta_samples = 0
              
              # rotator
              self.rotcnt = 0
              self.rotphase = 1 + 0j
              self.rotphaseinc = 1 + 0j

              # get next pass
              # sat predictor input expects utc time zone!
              predicted_pass = self.satpredictor.get_next_pass(self.location, self.current_time_utc, max_elevation_gt = 0)

              print("Next pass of {0} / AOS: {1} ({2}) / LOS: {3} ({4}) / Duration: {5:.2f} s / Max Elevation: {6:.1f} deg".format(
                       self.sat_name,
                       predicted_pass.aos.astimezone(self.time_zone), # output in local timezone
                       self.time_zone,
                       predicted_pass.los.astimezone(self.time_zone), # output in local timezone
                       self.time_zone,
                       predicted_pass.duration_s,
                       predicted_pass.max_elevation_deg                 
                       ) 
                   )
              print("")



          def get_sat_elev_azim(self, sat_position):
             """ get elevation and azimuth on our location to sat at its position """
             
             [azim, elev] = self.location.get_azimuth_elev_deg( sat_position )
             
             return [elev, azim]



          def get_doppler_factor(self, sat_position):
             """ get doppler factor """
             
             return self.location.doppler_factor( sat_position )



          def get_doppler_shift(self, sat_position, freq):
             """ get doppler shift """
             
             return round(freq - (self.location.doppler_factor( sat_position ) * freq) )



          def get_sat_distance(self, sat_position_efec):
             """ get distance to satellite """
             
             return self.location.slant_range_km( sat_position_efec )



          def get_sat_distance_velocity(self, sat_position):
             """ get distance to satellite change rate """
             
             return self.location.slant_range_velocity_kms( sat_position )
          


          def get_is_visible(self, sat_position):
             """ is satellite visible from our location? """
             
             return self.location.is_visible ( sat_position )



          def set_corr_phase_inc(self, freqdev):
             """ Set Phase increment """
             
             self.rotphaseinc = np.exp( complex(0, (freqdev * 2* np.pi) / self.samp_rate) )

             

          def rotate(self, z):
             """ Rotate complex number z by phase """
             
             self.rotcnt += 1
             
             z = z * self.rotphase # rotate z by phase
             self.rotphase = self.rotphase * self.rotphaseinc # increment rotating phase
             
             if (self.rotcnt % 512) == 0:
                # keep rotation vector normalized to avoid unwanted gain
                self.rotphase = self.rotphase / np.abs(self.rotphase)
             
             return z
          


          def print_position_debug(self, sat_pos):
             """ Print debug information for current sat position """
             
             if ( self.print_debug != 0 and sat_pos != None ):
                 
                [elev, azim] = self.get_sat_elev_azim(sat_pos)
                 
                print( "{0} / Elevation: {1:.1f} deg / Azimuth: {2:.1f} deg / Distance: {3:.3f} km / Doppler Shift (@{4:.6f} MHz = {5} Hz / Corr {6} / Visible: {7}".format(
                         self.current_time_utc.astimezone(self.time_zone),
                         elev,
                         azim,
                         self.get_sat_distance(sat_pos.position_ecef),
                         self.rx_freq/1000000,
                         self.get_doppler_shift(sat_pos, self.rx_freq),
                         'RX' if self.direction == -1 else 'TX',
                         self.get_is_visible(sat_pos)
                         ) 
                      )    



          def work(self, input_items, output_items):
              """ worker """
             
              #print(self.num_delta_samples)
              
              if (self.num_delta_samples == 0) or (self.num_delta_samples > self.samp_rate):
                 # first call or passed time > 1s since last call
                 
                 # calc current time
                 self.current_time_utc += datetime.timedelta( seconds = self.num_delta_samples/self.samp_rate )
                 
                 # get new sat position
                 sat_pos = self.satpredictor.get_position(self.current_time_utc)
              
                 # set frequency correction
                 self.set_corr_phase_inc( self.get_doppler_shift(sat_pos, self.rx_freq) * self.direction )

                 # print time and position info if debug is on
                 self.print_position_debug(sat_pos)
                 
                 # start new 1s timer
                 self.num_delta_samples = 0
                 

              self.num_delta_samples += len(input_items[0]) 

              # fixme. what if more changes in this vector? interpolate correction?
              for i in range( len(input_items[0]) ):
                 output_items[0][i] = self.rotate(input_items[0][i])

              return len(output_items[0])
    comment: |-
      Method 2:
      Correction of doppler shift
    direction: direction
    loc_height_m: loc_height
    loc_lat: loc_lat
    loc_lon: loc_lon
    loc_name: loc_name
    print_debug: print_debug
    rx_freq: rx_freq
    samp_rate: samp_rate
    sat_name: sat_name
    start_time: start_time
    time_zone: time_zone
    tle_file: tle_file
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import blocks

      import pmt

      from orbit_predictor.sources import EtcTLESource
      import orbit_predictor.locations
      import datetime
      import pytz


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, samp_rate=1e6,
                       rx_freq=145.8e6,
                       direction='RX',
                       loc_name='Nuernberg', loc_lat=49.478, loc_lon=11.069, loc_height_m=315, 
                       tle_file='/home/real/iss.txt', sat_name='ISS (ZARYA)',
                       start_time='2021-01-01 00:00:00',
                       time_zone='Europe/Berlin',
                       print_debug=1):
              """arguments to this function show up as parameters in GRC"""

              gr.sync_block.__init__(
                  self,
                  name='Satellite Doppler Shift Prediction',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.message_port_register_out(pmt.intern('msgfreq'))
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              print("*** Satellite Doppler Frequency Shift Prediction ***")
              
              # sample rate
              self.samp_rate = samp_rate
              
              # rx frequency
              self.rx_freq = rx_freq
              
              # rx or tx correction?
              if direction.lower() == 'rx':
                 self.direction = -1
              else:
                 self.direction = 1
              
              # location
              self.loc_name = loc_name
              self.loc_lat = loc_lat
              self.loc_lon = loc_lon
              self.loc_height_m = loc_height_m
              self.location = orbit_predictor.locations.Location(self.loc_name, self.loc_lat, self.loc_lon, self.loc_height_m)
              
              # read iss tle
              self.tle_file = tle_file
              self.tlesource = EtcTLESource(filename=self.tle_file)

              # sat predictor
              self.sat_name = sat_name
              print("Satellite: " + self.sat_name)
              self.satpredictor = self.tlesource.get_predictor(self.sat_name)
              
              # destination timezone
              try:
                 self.time_zone = pytz.timezone(time_zone)
              except:
                 print("WARNING: Invalid time zone. Assuming UTC.")
                 self.time_zone = pytz.timezone('UTC')
              
              self.time_zone_utc = pytz.timezone('UTC')
              
              # start time
              try:
                 self.start_time = datetime.datetime.strptime(start_time, '%Y-%m-%d %H:%M:%S')
                 self.start_time = self.time_zone.localize(self.start_time)
              except:
                 print("WARNING: No valid start time given. Use now()")
                 self.start_time = datetime.datetime.now(self.time_zone)

              self.current_time_utc = self.start_time.astimezone(self.time_zone_utc)
              print("Start Time: " + str(self.current_time_utc.astimezone(self.time_zone)) + " (" + str(self.time_zone) + ")" )

              self.print_debug = print_debug

              # other variables
              self.num_delta_samples = 0
              self.last_freq_corr_msg = 0

              # get next pass
              # sat predictor input expects utc time zone!
              predicted_pass = self.satpredictor.get_next_pass(self.location, self.current_time_utc, max_elevation_gt = 0)

              print("Next pass of {0} / AOS: {1} ({2}) / LOS: {3} ({4}) / Duration: {5:.2f} s / Max Elevation: {6:.1f} deg".format(
                       self.sat_name,
                       predicted_pass.aos.astimezone(self.time_zone), # output in local timezone
                       self.time_zone,
                       predicted_pass.los.astimezone(self.time_zone), # output in local timezone
                       self.time_zone,
                       predicted_pass.duration_s,
                       predicted_pass.max_elevation_deg                 
                       ) 
                   )
              print("")


          def get_sat_elev_azim(self, sat_position):
             """ get elevation and azimuth on our location to sat at its position """
             
             [azim, elev] = self.location.get_azimuth_elev_deg( sat_position )
             
             return [elev, azim]



          def get_doppler_factor(self, sat_position):
             """ get doppler factor """
             
             return self.location.doppler_factor( sat_position )



          def get_doppler_shift(self, sat_position, freq):
             """ get doppler shift """
             
             return round( freq - self.location.doppler_factor( sat_position ) * freq)



          def get_sat_distance(self, sat_position_efec):
             """ get distance to satellite """
             
             return self.location.slant_range_km( sat_position_efec )



          def get_sat_distance_velocity(self, sat_position):
             """ get distance to satellite """
             
             return self.location.slant_range_velocity_kms( sat_position )
          


          def get_is_visible(self, sat_position):
             """ is satellite visible from our location? """
             
             return self.location.is_visible ( sat_position )



          def print_position_debug(self, sat_pos):
             """ Print debug information for current sat position """
             
             if ( self.print_debug != 0 and sat_pos != None ):
                 
                [elev, azim] = self.get_sat_elev_azim(sat_pos)
                 
                print( "{0} / Elevation: {1:.1f} deg / Azimuth: {2:.1f} deg / Distance: {3:.3f} km / Doppler Shift (@{4:.6f} MHz = {5} Hz / Corr {6} / Visible: {7}".format(
                         self.current_time_utc.astimezone(self.time_zone),
                         elev,
                         azim,
                         self.get_sat_distance(sat_pos.position_ecef),
                         self.rx_freq/1000000,
                         self.get_doppler_shift(sat_pos, self.rx_freq),
                         'RX' if self.direction == -1 else 'TX',
                         self.get_is_visible(sat_pos)
                         ) 
                      )    



          def work(self, input_items, output_items):
              """ worker """
             
              #print(self.num_delta_samples)

              if (self.num_delta_samples == 0) or (self.num_delta_samples > self.samp_rate):
                 # first call or passed time > 1s since last call
                 
                 # calc current time
                 self.current_time_utc += datetime.timedelta( seconds = self.num_delta_samples/self.samp_rate )
                 
                 # get new sat position
                 sat_pos = self.satpredictor.get_position(self.current_time_utc)
              
                 # send frequency correction message
                 doppler_freq_corr = self.get_doppler_shift(sat_pos, self.rx_freq) * self.direction
                 self.message_port_pub(pmt.intern('msgfreq'), pmt.cons(pmt.to_pmt("freq"), pmt.from_float(doppler_freq_corr)))
                 self.last_freq_corr_msg = doppler_freq_corr

                 # print time and position info if debug is on
                 self.print_position_debug(sat_pos)
                 
                 # start new 1s timer
                 self.num_delta_samples = 0


              self.num_delta_samples += len(input_items[0]) 

              output_items[0][:] = input_items[0]
              
              return len(output_items[0])
    comment: |-
      Method 1: 
      Prediction of doppler shift 
      with correction afterwards
    direction: direction
    loc_height_m: loc_height
    loc_lat: loc_lat
    loc_lon: loc_lon
    loc_name: loc_name
    print_debug: '1'
    rx_freq: rx_freq
    samp_rate: samp_rate
    sat_name: sat_name
    start_time: start_time
    time_zone: time_zone
    tle_file: tle_file
  states: {}
- name: loc_height
  id: parameter
  parameters:
    label: Location Height [m]
    value: '315'
  states: {}
- name: loc_lat
  id: parameter
  parameters:
    label: Location Latitude
    value: '49.478'
  states: {}
- name: loc_lon
  id: parameter
  parameters:
    label: Location Longitude
    value: '11.069'
  states: {}
- name: loc_name
  id: parameter
  parameters:
    comment: Receiver Location
    label: Location Name
    type: str
    value: '''Nuremberg'''
  states: {}
- name: print_debug
  id: parameter
  parameters:
    hide: part
    label: Print Debug Messages
    type: intx
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Doppler correction
    label2: Original Signal
    label3: Doppler correction (rotator)
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: Receive Frequency
    value: 145.8e6
  states: {}
- name: sat_name
  id: parameter
  parameters:
    label: Satellite Name
    type: str
    value: '''ISS (ZARYA)'''
  states: {}
- name: start_time
  id: parameter
  parameters:
    label: Start Time
    type: str
    value: '''2021-01-02 08:09:15'''
  states: {}
- name: time_zone
  id: parameter
  parameters:
    label: Time Zone
    type: str
    value: '''Europe/Berlin'''
  states: {}
- name: tle_file
  id: parameter
  parameters:
    label: Location of TLE file
    type: str
    value: /tmp/iss.txt
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', epy_block_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '1']
- [epy_block_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '2']
- [epy_block_0_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0_0, msgfreq, analog_sig_source_x_0_0, freq]

metadata:
  file_format: 1
