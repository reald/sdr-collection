options:
  parameters:
    author: reald
    generate_options: qt_gui
    id: sat_doppler_corr_example
    output_language: python
    title: sat_doppler_corr_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/korrekturverlauf_korrigiert_hier.cfile
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/korrekturverlauf.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*8
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Doppler correction
    label2: Original Signal
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: sat_doppler_corr_0
  id: sat_doppler_corr
  parameters:
    loc_height: '315'
    loc_lat: '49.478'
    loc_lon: '11.069'
    loc_name: '''Nuremberg'''
    print_debug: '0'
    rx_freq: 145.8e6
    samp_rate: samp_rate
    sat_name: '''ISS (ZARYA)'''
    start_time: '''2021-01-02 08:09:15'''
    time_zone: '''Europe/Berlin'''
    tle_file: /tmp/iss.txt
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle_0, '0', sat_doppler_corr_0, '0']
- [sat_doppler_corr_0, '0', blocks_file_sink_0, '0']
- [sat_doppler_corr_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
