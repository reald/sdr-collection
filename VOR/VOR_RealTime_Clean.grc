options:
  parameters:
    generate_options: qt_gui
    id: VOR_Receive_RealTime_Clean
    output_language: python
  states: {}

blocks:
- name: morse_gain
  id: variable
  parameters:
    value: pow(10,morse_vol/10)
  states: {}
- name: morse_vol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-25'
    step: '1'
    stop: '25'
    value: '1'
  states: {}
- name: rtl_freq
  id: variable
  parameters:
    value: 115.5e6+64
  states: {}
- name: rtl_gain
  id: variable
  parameters:
    value: '42'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '12000'
    audio_stop: '13000'
    chan_rate: samp_rate
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '100'
    audio_stop: '200'
    chan_rate: samp_rate
    deviation: '1000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-9960'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '32000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1030'
    low_cutoff_freq: '1010'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '360'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/dvor_simulation.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: morse_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-180/pi'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/360.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normal modulo would be easier here.
    const: '-360'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1'
    init: '0'
    low: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    comment: compensate fm demod lp filter
    decim: '1'
    taps: filter.optfir.low_pass(1, samp_rate, 100, 200, 0.1,  60)
    type: fff
  states: {}
- name: goertzel_fc_0
  id: goertzel_fc
  parameters:
    freq: '30'
    len: '3200'
    rate: samp_rate
  states: {}
- name: goertzel_fc_0_0
  id: goertzel_fc
  parameters:
    freq: '30'
    len: '3200'
    rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    comment: compensate pre fm demod lp filter
    cutoff_freq: '1000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Original source:

      https://github.com/radiojitter/RTLVOR

      Related article:

      https://www.radiojitter.com/real-time-decoding-of-vor-using-rtl-sdr/
    note: References
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: '0'
    decim: '64'
    taps: firdes.low_pass(1,samp_rate*64,16e3,200e3)
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Radial:"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '200'
    srate: samp_rate/1000
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '1'
    taps: firdes.low_pass(1,96000,16e3,1e3)
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: rtl_freq
    gain0: rtl_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*64
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: REF30
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: VAR30
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: MORSE
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: DataSource
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: REF30
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: VAR30
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: DataSource
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: MORSE
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: DataSource
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: DataSource
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', virtual_sink_0_1_0, '0']
- [analog_fm_demod_cf_0, '0', goertzel_fc_0_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0_0, '1']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_0_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_integrate_xx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_throttle_0, '0', analog_am_demod_cf_0, '0']
- [fir_filter_xxx_0_0, '0', goertzel_fc_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [goertzel_fc_0, '0', virtual_sink_0, '0']
- [goertzel_fc_0_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_1, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0_1_0, '0', fir_filter_xxx_0_0, '0']
- [pfb_decimator_ccf_0, '0', analog_agc3_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rtlsdr_source_0, '0', pfb_decimator_ccf_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0_1, '0', band_pass_filter_0, '0']
- [virtual_source_0_1_0, '0', blocks_integrate_xx_1, '0']
- [virtual_source_0_2, '0', low_pass_filter_0_1_0, '0']
- [virtual_source_0_2_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
