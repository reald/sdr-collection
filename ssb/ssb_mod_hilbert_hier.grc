options:
  parameters:
    author: reald
    description: SSB Modulation using Hilbert transform. LSB and USB are supported, unused ports can be left open.
    generate_options: hb
    id: SSB_Mod_Hilbert_Hier
    output_language: python
    title: SSB Mod (Hilbert)
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Woraround  to handle optional input sources 
      (Imag part of float to complex block can be unconnected)
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Woraround  to handle optional input sources 
      (Imag part of float to complex block can be unconnected)
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: numhilberttaps
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_1
  id: hilbert_fc
  parameters:
    num_taps: numhilberttaps
    win: firdes.WIN_HAMMING
  states: {}
- name: numhilberttaps
  id: parameter
  parameters:
    hide: part
    label: Number Hilbert Taps
    type: intx
    value: '999'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: baseband
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: LSB
    optional: 'True'
    type: float
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: USB
    optional: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '96000'
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', rational_resampler_xxx_0_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_add_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_complex_to_float_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_null_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_add_xx_0, '0']
- [hilbert_fc_0_1, '0', blocks_conjugate_cc_0, '0']
- [pad_source_1, '0', blocks_float_to_complex_0_0, '1']
- [pad_source_1_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', hilbert_fc_0_0, '0']
- [rational_resampler_xxx_0_1, '0', hilbert_fc_0_1, '0']

metadata:
  file_format: 1
