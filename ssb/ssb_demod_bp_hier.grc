options:
  parameters:
    author: reald
    description: SSB Demodulation using complex bandpasses. LSB and USB are supported, unused ports can be left open.
    generate_options: hb
    id: SSB_Demod_BP_Hier
    output_language: python
    title: SSB Demod (BP)
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: bp_hi_cutoff
    low_cutoff_freq: bp_lo_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: bp_transistionw
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '-bp_lo_cutoff'
    low_cutoff_freq: '-bp_hi_cutoff'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: bp_transistionw
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters:
    comment: would work, too
  states: {}
- name: blocks_complex_to_imag_0_0
  id: blocks_complex_to_imag
  parameters:
    comment: would work, too
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: needed if optional output port is not connected
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    comment: needed if optional output port is not connected
    type: float
  states: {}
- name: bp_hi_cutoff
  id: parameter
  parameters:
    label: BP High Cut Off Freq
    type: intx
    value: '3500'
  states: {}
- name: bp_lo_cutoff
  id: parameter
  parameters:
    label: BP Low Cut Off Freq
    type: intx
    value: '200'
  states: {}
- name: bp_transistionw
  id: parameter
  parameters:
    label: BP Transistion Width
    type: intx
    value: '100'
  states: {}
- name: numhilberttaps
  id: parameter
  parameters:
    hide: part
    label: Number Hilbert Taps
    type: intx
    value: '999'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: USB
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: LSB
    optional: 'True'
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: baseband
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '96000'
  states: {}

connections:
- [band_pass_filter_0_0, '0', blocks_complex_to_imag_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_real_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_complex_to_imag_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_imag_0_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_real_0_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_1, '0', band_pass_filter_0_0, '0']
- [pad_source_1, '0', band_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_null_sink_1, '0']
- [rational_resampler_xxx_0, '0', pad_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_null_sink_1_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
