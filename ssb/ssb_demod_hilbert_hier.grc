options:
  parameters:
    author: reald
    description: SSB Demodulation using Hilbert transform. LSB and USB are supported, unused ports can be left open.
    generate_options: hb
    id: SSB_Demod_Hilbert_Hier
    output_language: python
    title: SSB Demod (Hilbert)
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: needed if optional output port is not connected
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    comment: needed if optional output port is not connected
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: high_pass_cutoff
  id: parameter
  parameters:
    hide: part
    label: High Pass Cut Off Freq
    type: intx
    value: '200'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: high_pass_cutoff
    decim: '1'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: high_pass_transistionw
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: high_pass_cutoff
    decim: '1'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: high_pass_transistionw
    win: firdes.WIN_HAMMING
  states: {}
- name: high_pass_transistionw
  id: parameter
  parameters:
    hide: part
    label: High Pass Transistion Width
    type: intx
    value: '100'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: numhilberttaps
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: numhilberttaps
    win: firdes.WIN_HAMMING
  states: {}
- name: numhilberttaps
  id: parameter
  parameters:
    hide: part
    label: Number Hilbert Taps
    type: intx
    value: '999'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: LSB
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: USB
    optional: 'True'
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: baseband
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '96000'
  states: {}

connections:
- [blocks_add_xx_0, '0', high_pass_filter_0_0, '0']
- [blocks_complex_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_float_0, '1', hilbert_fc_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_0_1, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0_1, '1', blocks_add_xx_0, '1']
- [blocks_complex_to_float_0_1, '1', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [high_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_float_0_1, '0']
- [pad_source_1, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_null_sink_1, '0']
- [rational_resampler_xxx_0, '0', pad_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_null_sink_1_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
