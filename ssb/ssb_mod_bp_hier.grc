options:
  parameters:
    author: reald
    description: SSB Modulation using complex bandpasses. LSB and USB are supported, unused ports can be left open.
    generate_options: hb
    id: SSB_Mod_BP_Hier
    output_language: python
    title: SSB Mod (BP)
  states: {}

blocks:
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: intx
    value: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: bp_hi_cutoff
    low_cutoff_freq: bp_lo_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: bp_transistionw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '-bp_lo_cutoff'
    low_cutoff_freq: '-bp_hi_cutoff'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: bp_transistionw
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Workaround: Use Imag part because it can be left open 
      (source port is optional)
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Workaround: Use Imag part because it can be left open 
      (source port is optional)
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: bp_hi_cutoff
  id: parameter
  parameters:
    label: BP High Cut Off Freq
    type: intx
    value: '3500'
  states: {}
- name: bp_lo_cutoff
  id: parameter
  parameters:
    label: BP Low Cut Off Freq
    type: intx
    value: '200'
  states: {}
- name: bp_transistionw
  id: parameter
  parameters:
    label: BP Transistion Width
    type: intx
    value: '100'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: baseband
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: LSB
    optional: 'True'
    type: float
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: USB
    optional: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    taps: ''
    type: ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: intx
    value: '96000'
  states: {}

connections:
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_null_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [pad_source_1, '0', blocks_float_to_complex_0_0, '1']
- [pad_source_1_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', band_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_1, '0', band_pass_filter_0_0_0, '0']

metadata:
  file_format: 1
