options:
  parameters:
    author: reald  / TMS
    generate_options: qt_gui
    id: gr_foxhunting
    output_language: python
    title: Example Foxhunting CW Receiver for RTL-SDR
  states: {}

blocks:
- name: Hints_Label
  id: variable_qtgui_label
  parameters:
    comment: |-
      1. If frequency sinks updates SLOW, change the FFT size!
      2. Try to keep constant peaks in the blue spectrum out of your filtered channel (red)
      3. The foxes transmit between 144.000000 and 144.010000 Mhz!
    gui_hint: 5,0,1,3
    label: '''Hints:'''
    type: string
    value: '''1. If frequency sinks updates SLOW, change the FFT size!\n2. Try to keep constant peaks in the blue spectrum out of your filtered channel (red)\n3. The foxes transmit between 144.000000 and 144.010000 Mhz!\n'''
  states: {}
- name: base_decim
  id: variable
  parameters:
    value: '16'
  states: {}
- name: complexity_lp1
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.6f} M'''
    gui_hint: 6,0,1,2
    label: 'Complexity LP1: '
    type: real
    value: len(variable_low_pass_filter_taps_0) * samp_rate / 1e6
  states: {}
- name: complexity_lp2
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.6f} M'''
    gui_hint: 6,2,1,1
    label: 'Complexity LP2: '
    type: real
    value: len(variable_low_pass_filter_taps_1) * int(samp_rate/base_decim) / 1e6
  states: {}
- name: cut
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: Channel Filter Cutoff Frequency [Hz]
    min_len: '50'
    start: '200'
    step: '25'
    stop: '10000'
    value: '2500'
  states: {}
- name: freq
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,1,1,1
    maximum: '10000'
    minimum: '0'
    showvalue: 'True'
    type: real
    value: '3000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: HW Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: 29.7-20
  states: {}
- name: hwfreq
  id: variable
  parameters:
    value: 144.05e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.024e6
  states: {}
- name: tw
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Channel Filter Transistion width [Hz]
    min_len: '50'
    start: '10'
    step: '25'
    stop: '10000'
    value: '500'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '15000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut
    gain: '1.0'
    samp_rate: samp_rate/base_decim
    width: tw
    win: window.WIN_HAMMING
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: f''{x:.6f} MHz'''
    gui_hint: 2,1,1,3
    label: Resulting Frequency
    type: real
    value: int(144e6 + freq)/1e6
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'Channel Frequency Tuning: '
    type: string
    value: 144Mhz + ...
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 2, 1, 1
    label: Audio Volume
    min_len: '50'
    start: '0'
    step: '.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: volume
    freq: '700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Channel Filter
    decim: '1'
    taps: variable_low_pass_filter_taps_1
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-(hwfreq-144e6)+freq'
    comment: Pre Filter
    decim: base_decim
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: hwfreq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/base_decim
    ctrlpanel: 'True'
    fc: 144e6+freq
    fftsize: '16384'
    grid: 'True'
    gui_hint: 4,0,1,3
    label1: Unfiltered Bandwidth
    label2: Filtered Channel
    nconnections: '2'
    showports: 'True'
    type: complex
    update_time: '0.064'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/base_decim
    fc: 144e6+freq
    fftsize: '1024'
    gui_hint: 1,2,1,1
    name: '"Waterfall"'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/base_decim)
    interp: '48000'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_1, '0', audio_sink_0, '0']
- [blocks_complex_to_float_1, '0', blocks_add_xx_1, '0']
- [blocks_complex_to_float_1, '1', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_complex_to_float_1, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [fir_filter_xxx_0, '0', rational_resampler_xxx_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_xx_0_0_0, '0']

metadata:
  file_format: 1
